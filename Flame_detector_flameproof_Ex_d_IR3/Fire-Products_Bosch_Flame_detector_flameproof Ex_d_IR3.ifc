Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2022-11-04T10:43:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 04 10:43:24 2022 * Host: LIS-C-00085 * Database: C:\Users\JAL1OVR\AppData\Local\Temp\{43AFABFA-CCEA-4F9D-9D1D-FDF211B434B4}\ifc * Database version: 5507 * Database creation date: Fri Nov 04 10:43:23 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 04 10:43:23 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 04 10:43:23 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Ebene
Graphics(Type) - Color: 16711680; Line Pattern: Verdeckt; Line Weight: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 m
Dimensions - Computation Height: 0 m
Identity Data - Building Story: yes; Name: Ebene 0; Structural: no
Other - Category: Levels; Family: Level: Ebene; Family and Type: Level: Ebene; Type: Level: Ebene; Type Id: Level: Ebene

# IfcDistributionControlElement: Flame detector, Flame detector flameproof Ex d, IR3:016519_Flame_detector_flameproof_Ex_d_IR3:404108
In: Ebene 0
Type - PredefinedType: FIRESENSOR; Classification: Pr_75_75_30_63 Point flame detectors (Uniclass 2015); Material: Bosch_Red
Type - Constraints - Commercial Type Number: 016519; Default Elevation: 2.1 m
Type - Identity Data - CTN: 016519; Description: IR3 detector for open flames, suitable for explosive areas, red color.; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/IR3_Flame_Detector_E_Installation_Manual_enUS_16566335627.pdf; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.21.11.11; OmniClass Title: Fire/Smoke Detectors; PlanningTools: https://media.boschsecurity.com/fs/media/pb/media/support_1/tools/safety-systems-designer.zip; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/IR3_Exd_Data_sheet_enUS_11803981579.pdf; Product Website: https://commerce.boschsecurity.com/nlexp/en/Flame-detector-flameproof-Ex-d-IR3/p/F.01U.279.764/; Type Name: 016519_Flame_detector_flameproof_Ex_d_IR3
Type - Other - Category: Fire Alarm Devices; Color: Red; Dimension (H x W x D) in mm: 150 x 146 x 137 mm; Family Name: Flame detector flameproof Ex d, IR3; IP rating: IP65; Material: Aluminum; Operating temperature (°C): -10 – 55 °C; Operating voltage (VDC): 14 to 30 V DC; Weight (g): 2500 g
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 m; Host: Level : Ebene 0; Level: Level: Ebene 0
Dimensions - Area: 0.0472725 m2; Volume: 0.00223108 m3
Identity Data - Mark: 3
Other - Family: Flame detector flameproof Ex d, IR3: 016519_Flame_detector_flameproof_Ex_d_IR3; Family and Type: Flame detector flameproof Ex d, IR3: 016519_Flame_detector_flameproof_Ex_d_IR3; Schedule Level: Level: Ebene 0; Type: Flame detector flameproof Ex d, IR3: 016519_Flame_detector_flameproof_Ex_d_IR3; Type Id: Flame detector flameproof Ex d, IR3: 016519_Flame_detector_flameproof_Ex_d_IR3
Phasing - Phase Created: Phase 1
